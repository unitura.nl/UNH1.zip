Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: C:\Users\DennisHoogenboezem\HSR Groep BV\Unitura - Documenten (2)\R&D\Producttekeningen\1. HOUTEN VOORZIENINGEN (wood)\GOOTKASTEN (gutter boxes)\UNG1-UNH1-UNV1\UNH1 brontekeningen\UNH1.IFC
Time: 2026-02-05T11:37:12+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3

# IfcProject, Project
Description: Default Project
